REPO = "git://github.com/spacecubics/qemu-devicetrees.git;protocol=https"
BRANCH = "scobc-v1"
SRCREV = "410e2e591277ac203c904cf90e66b8de17b4cb63"
