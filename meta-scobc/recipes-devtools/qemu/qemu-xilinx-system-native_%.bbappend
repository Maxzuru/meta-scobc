REPO = "gitsm://github.com/spacecubics/xlnx-qemu.git;protocol=https"
BRANCH = "safety_processor"
SRCREV = "e48a13b46da09d50babfe57a654aadce7ce28aab"
